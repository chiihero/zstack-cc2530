# IAR project Boot.ewp, settings and files
configuration OAD Boot Loader (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: HAL_OAD_BOOT_CODE
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; Source; ..\..\..\Tools\CC2530DB; ..\..\..\ZMain\TI2530DB; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\osal\include
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: ..\..\..\Tools\CC2530DB\oad-boot.xcl
  group App
    ../../../../../Components/osal/include/: comdef.h
  group HAL/Include
    ../../../../../Components/hal/include/: hal_defs.h
  group HAL/Target/CC2530EB/Config
    ../../../../../Components/hal/target/CC2530EB/: hal_board_cfg.h
  group HAL/Target/CC2530EB/Drivers
    ../../../../../Components/hal/target/CC2530EB/: hal_flash.c hal_oad.c
  group HAL/Target/CC2530EB/Includes
    ../../../../../Components/hal/target/CC2530EB/: hal_dma.h hal_mcu.h hal_oad.h hal_types.h
    ../../../../../Components/hal/include/: hal_flash.h hal_xnv.h
  group Tools
    ../../../ZMain/TI2530DB/: chipcon_cstartup.s51
    source/: interrupt_stubs.s51
    ../../../Tools/CC2530DB/: oad-boot.xcl
