# IAR project Boot.ewp, settings and files
configuration CC2531 Boot Loader (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2531F256.i51
  ICC8051.CCDefines: HAL_SB_BOOT_CODE
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\Source; source; ..\..\..\ZMAIN\TI2530DB; ..\..\..\..\..\COMPONENTS\HAL\INCLUDE; ..\..\..\..\..\COMPONENTS\HAL\TARGET\_COMMON\CC2530; ..\..\..\..\..\COMPONENTS\HAL\TARGET\CC2530USB; ..\..\..\..\..\COMPONENTS\HAL\TARGET\CC2530USB\usb\library; ..\..\..\..\..\COMPONENTS\HAL\TARGET\CC2530USB\usb\library\cc2531; ..\..\..\..\..\COMPONENTS\HAL\TARGET\CC2530USB\usb\class_cdc; ..\..\..\..\..\COMPONENTS\OSAL\INCLUDE; ..\..\..\..\..\COMPONENTS\SERVICES\SADDR
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: ..\..\..\Tools\CC2530DB\sb-boot.xcl
  group App
    ../../../../../COMPONENTS/osal/include/: comdef.h
    ../Source/: sb_exec.c sb_exec.h
    source/: sb_main.c sb_main.h
  group HAL/Include
    ../../../../../COMPONENTS/hal/include/: hal_defs.h hal_flash.h hal_uart.h
  group HAL/Target/CC2530USB/Config
    ../../../../../COMPONENTS/hal/target/CC2530USB/: hal_board_cfg.h
  group HAL/Target/CC2530USB/Drivers
    ../../../../../Components/hal/target/CC2530USB/: hal_flash.c
  group HAL/Target/CC2530USB/Includes
    ../../../../../Components/hal/target/CC2530USB/: hal_dma.h
    ../../../../../COMPONENTS/hal/target/CC2530USB/: hal_mcu.h hal_types.h
  group HAL/Target/CC2530USB/USB/class_cdc
    ../../../../../Components/hal/target/CC2530USB/usb/class_cdc/: usb_cdc.h usb_cdc_descriptor.s51 usb_cdc_hooks.c usb_cdc_hooks.h usb_firmware_library_config.c
    ../../../../../COMPONENTS/hal/target/CC2530USB/usb/class_cdc/: usb_firmware_library_config.h usb_firmware_library_headers.h
  group HAL/Target/CC2530USB/USB/library
    ../../../../../COMPONENTS/hal/target/CC2530USB/usb/library/: usb_descriptor.h usb_descriptor_parser.h usb_framework.h usb_framework_structs.h usb_interrupt.h usb_reg.h usb_standard_requests.h usb_suspend.h
    ../../../../../Components/hal/target/CC2530USB/usb/library/: usb_descriptor_parser.c usb_framework.c usb_standard_requests.c
  group HAL/Target/CC2530USB/USB/library/cc2531
    ../../../../../COMPONENTS/hal/target/CC2530USB/usb/library/cc2531/: usb_board_cfg.h
    ../../../../../Components/hal/target/CC2530USB/usb/library/cc2531/: usb_interrupt.c usb_suspend.c
  group Tools
    ../../../ZMain/TI2530DB/: chipcon_cstartup.s51
    source/: interrupt_stubs.s51
    ../../../Tools/CC2530DB/: sb-boot.xcl
