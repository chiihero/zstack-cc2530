# IAR project Boot.ewp, settings and files
configuration CC2530ZNP Boot Loader (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: HAL_SB_BOOT_CODE; HAL_UART_SPI=2
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\Source; source; ..\..\..\ZMAIN\TI2530ZNP; ..\..\..\..\..\COMPONENTS\HAL\INCLUDE; ..\..\..\..\..\COMPONENTS\HAL\TARGET\_COMMON\CC2530; ..\..\..\..\..\COMPONENTS\HAL\TARGET\CC2530ZNP; ..\..\..\..\..\COMPONENTS\OSAL\INCLUDE; ..\..\..\..\..\COMPONENTS\SERVICES\SADDR
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: ..\..\..\Tools\CC2530DB\sb-boot.xcl
configuration CC2530-MK Boot Loader (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: HAL_SB_BOOT_CODE; HAL_UART_SPI=1; CC2530_MK
  group App
    ../../../../../COMPONENTS/osal/include/: comdef.h
    ../Source/: sb_exec.c sb_exec.h
    source/: sb_main.c sb_main.h
  group HAL/Include
    ../../../../../COMPONENTS/hal/include/: hal_defs.h hal_flash.h hal_uart.h
  group HAL/Target/CC2530ZNP/Config
    ../../../../../COMPONENTS/hal/target/CC2530ZNP/: hal_board_cfg.h
  group HAL/Target/CC2530ZNP/Drivers
    ../../../../../Components/hal/target/CC2530ZNP/: hal_flash.c
  group HAL/Target/CC2530ZNP/Includes
    ../../../../../Components/hal/target/CC2530ZNP/: hal_dma.h hal_mcu.h hal_types.h
  group Tools
    ../../../ZMain/TI2530ZNP/: chipcon_cstartup.s51
    source/: interrupt_stubs.s51
    ../../../Tools/CC2530DB/: sb-boot.xcl
